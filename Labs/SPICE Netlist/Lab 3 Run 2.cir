** Lab 3 Run 2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Chris
* Wed, Oct 31, 2018 19:42:07
*

*## Multisim Component U4 ##*
aU4  [8 18] 7 AND2__TIL__1

*## Multisim Component U3 ##*
aU3 11 18 NOT__TIL__1

*## Multisim Component U2 ##*
* !!!BEGIN-INTERACT
*  1.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_MODEL_INSTANCE d_constsource digital_source  a1 state
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xU2 U2_OPEN_OUT digital_sourceU2

.subckt digital_sourceU2 OUT

a1 OUT digital_source
.model digital_source d_constsource(state=0)

.ends

*## Multisim Component U1 ##*
aU1  [12 13
+     14 15
+     16 17] 11 XOR2__TIL__1

*## Multisim Component X2 ##*
* !!!BEGIN-INTERACT
*  0.0       VARIABLE pin_index
*  0.0       VARIABLE pin_state
*
*  :ON_USER_UPDATE
*       0 7 0 SET_SUBCOMP_PRP
*       0 8 0 SET_SUBCOMP_PRP
*       0 9 0 SET_SUBCOMP_PRP
*       0 10 0 SET_SUBCOMP_PRP
*       0 11 0 SET_SUBCOMP_PRP
*       0 12 0 SET_SUBCOMP_PRP
*       0 13 0 SET_SUBCOMP_PRP
*       0 14 0 SET_SUBCOMP_PRP
*  ;
*
*  :OUT_DATA
*   *pin_index GET_REAL_DATA ==>_*pin_state
*   0.9 *pin_state  f.<   if
*       1 7 0 SET_SUBCOMP_PRP
*       1 8 0 SET_SUBCOMP_PRP
*       1 9 0 SET_SUBCOMP_PRP
*       1 10 0 SET_SUBCOMP_PRP
*       1 11 0 SET_SUBCOMP_PRP
*       1 12 0 SET_SUBCOMP_PRP
*       1 13 0 SET_SUBCOMP_PRP
*       1 14 0 SET_SUBCOMP_PRP
*   else
*       0 7 0 SET_SUBCOMP_PRP
*       0 8 0 SET_SUBCOMP_PRP
*       0 9 0 SET_SUBCOMP_PRP
*       0 10 0 SET_SUBCOMP_PRP
*       0 11 0 SET_SUBCOMP_PRP
*       0 12 0 SET_SUBCOMP_PRP
*       0 13 0 SET_SUBCOMP_PRP
*       0 14 0 SET_SUBCOMP_PRP
*   endif
*  ;
*
*  :BEGIN_PLOT
*     GET_NODE_INDEX 1 ==>_*pin_index
*  ;
* !!!END-INTERACT
xX2 7 Probe_digX2
.subckt Probe_digX2 1
a1 1 2 InputBuffer
a2 2 Digload
.MODEL Digload d_pulldown(load = 1e-12)
.MODEL InputBuffer d_buffer (rise_delay = 1n fall_delay = 1n)
.ends

*## Multisim Component X1 ##*
* !!!BEGIN-INTERACT
*  0.0       VARIABLE pin_index
*  0.0       VARIABLE pin_state
*
*  :ON_USER_UPDATE
*       0 7 0 SET_SUBCOMP_PRP
*       0 8 0 SET_SUBCOMP_PRP
*       0 9 0 SET_SUBCOMP_PRP
*       0 10 0 SET_SUBCOMP_PRP
*       0 11 0 SET_SUBCOMP_PRP
*       0 12 0 SET_SUBCOMP_PRP
*       0 13 0 SET_SUBCOMP_PRP
*       0 14 0 SET_SUBCOMP_PRP
*  ;
*
*  :OUT_DATA
*   *pin_index GET_REAL_DATA ==>_*pin_state
*   0.9 *pin_state  f.<   if
*       1 7 0 SET_SUBCOMP_PRP
*       1 8 0 SET_SUBCOMP_PRP
*       1 9 0 SET_SUBCOMP_PRP
*       1 10 0 SET_SUBCOMP_PRP
*       1 11 0 SET_SUBCOMP_PRP
*       1 12 0 SET_SUBCOMP_PRP
*       1 13 0 SET_SUBCOMP_PRP
*       1 14 0 SET_SUBCOMP_PRP
*   else
*       0 7 0 SET_SUBCOMP_PRP
*       0 8 0 SET_SUBCOMP_PRP
*       0 9 0 SET_SUBCOMP_PRP
*       0 10 0 SET_SUBCOMP_PRP
*       0 11 0 SET_SUBCOMP_PRP
*       0 12 0 SET_SUBCOMP_PRP
*       0 13 0 SET_SUBCOMP_PRP
*       0 14 0 SET_SUBCOMP_PRP
*   endif
*  ;
*
*  :BEGIN_PLOT
*     GET_NODE_INDEX 1 ==>_*pin_index
*  ;
* !!!END-INTERACT
xX1 6 Probe_digX1
.subckt Probe_digX1 1
a1 1 2 InputBuffer
a2 2 Digload
.MODEL Digload d_pulldown(load = 1e-12)
.MODEL InputBuffer d_buffer (rise_delay = 1n fall_delay = 1n)
.ends

*## Multisim Component NOT_C ##*
aNOT_C 4 10 NOT__TIL__1

*## Multisim Component NOT_B ##*
aNOT_B 2 3 NOT__TIL__1

*## Multisim Component NOT_A ##*
aNOT_A 1 9 NOT__TIL__1

*## Multisim Component D ##*
* !!!BEGIN-INTERACT
*  1.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_MODEL_INSTANCE d_constsource digital_source  a1 state
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xD 5 digital_sourceD

.subckt digital_sourceD OUT

a1 OUT digital_source
.model digital_source d_constsource(state=0)

.ends

*## Multisim Component C ##*
* !!!BEGIN-INTERACT
*  1.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_MODEL_INSTANCE d_constsource digital_source  a1 state
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xC 4 digital_sourceC

.subckt digital_sourceC OUT

a1 OUT digital_source
.model digital_source d_constsource(state=0)

.ends

*## Multisim Component B ##*
* !!!BEGIN-INTERACT
*  1.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_MODEL_INSTANCE d_constsource digital_source  a1 state
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xB 2 digital_sourceB

.subckt digital_sourceB OUT

a1 OUT digital_source
.model digital_source d_constsource(state=0)

.ends

*## Multisim Component A ##*
* !!!BEGIN-INTERACT
*  1.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_MODEL_INSTANCE d_constsource digital_source  a1 state
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xA 1 digital_sourceA

.subckt digital_sourceA OUT

a1 OUT digital_source
.model digital_source d_constsource(state=0)

.ends

*## Multisim Component ABCD ##*
aABCD  [1 2
+     4 5] 17 AND2__TIL__1

*## Multisim Component _A_BCD ##*
a_A_BCD  [9 3
+     4 5] 16 AND2__TIL__1

*## Multisim Component AB_CD ##*
aAB_CD  [1 2
+     10 5] 15 AND2__TIL__1

*## Multisim Component A_B_CD ##*
aA_B_CD  [1 10
+     3 5] 14 AND2__TIL__1

*## Multisim Component _ABCD ##*
a_ABCD  [9 2
+     4 5] 13 AND2__TIL__1

*## Multisim Component _A_B_CD ##*
a_A_B_CD  [9 3
+     10 5] 12 AND2__TIL__1

*## Multisim Component _AB_CD_ALARM_ON ##*
a_AB_CD_ALARM_ON  [9 2
+     10 5] 8 AND2__TIL__1

*## Multisim Component A_BCD_UNLOCKED ##*
aA_BCD_UNLOCKED  [1 3
+     4 5] 6 AND2__TIL__1

.MODEL NOT__TIL__1 d_inverter (rise_delay = 1n fall_delay = 1n)

.MODEL AND2__TIL__1 d_and ( rise_delay = 1n fall_delay = 1n)

.MODEL XOR2__TIL__1 d_xor (rise_delay = 1n fall_delay = 1n)

* Allow simulation of an otherwise all digital circuit
v_dummy_alg_source v_dummy_alg_net_name 0 dc 0 ac 0 0
